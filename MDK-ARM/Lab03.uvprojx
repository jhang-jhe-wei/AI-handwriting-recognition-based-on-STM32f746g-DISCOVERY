# Keil uVision project Lab03.uvprojx, settings and files
target Lab03 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Lab03 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,ARM_MATH_CM7,__FPU_PRESENT=1
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Middlewares/ST/AI/Inc;../Middlewares/ST/Application/Validation/Inc;..\Drivers\BSP\STM32746G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: network.c network_data.c main.c app_x-cube-ai.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
    ../Utilities/Fonts/: font57.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Doc
    ..//: network_generate_report.txt
  group Drivers/CMSIS/DSP/Source/BasicMathFunctions
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_shift_q15.c arm_shift_q7.c
  group Drivers/CMSIS/DSP/Source/SupportFunctions
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_float_to_q7.c arm_float_to_q15.c arm_q7_to_float.c arm_q15_to_float.c arm_q7_to_q15.c arm_q15_to_q7.c arm_copy_q15.c arm_copy_q7.c arm_fill_q15.c arm_fill_q7.c
  group Drivers/CMSIS/DSP/Source/MatrixFunctions
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime410_CM7_Keil.lib
  group Middlewares/X-CUBE-AI/Artificial Intelligence/Application/Validation
    ../Middlewares/ST/Application/Validation/Src/: aiPbMgr.c aiTestUtility.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
  group BSP
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 4.3.0
